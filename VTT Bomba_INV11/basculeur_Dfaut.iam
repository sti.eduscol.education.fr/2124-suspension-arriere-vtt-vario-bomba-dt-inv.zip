# Autodesk Inventor assembly: basculeur_Dfaut
## iProperties
Created: 2006-03
Part Number: basculeur_Dfaut
Document SubType Name: Assembly
Designer: Flavien MARTY
Author: Flavien MARTY
