# Autodesk Inventor assembly: cadre_Dfaut
## iProperties
Created: 2006-03
Part Number: cadre_Dfaut
Document SubType Name: Assembly
Designer: Flavien MARTY
Author: Flavien MARTY
