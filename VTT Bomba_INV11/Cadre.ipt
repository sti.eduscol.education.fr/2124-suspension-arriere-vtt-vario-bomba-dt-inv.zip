# Autodesk Inventor part: cadre_v2
## iProperties
Created: 2006-03
Part Number: cadre_v2
Document SubType Name: Modeling
Designer: Flavien MARTY
Author: Flavien MARTY
## Feature names
1. Base1
