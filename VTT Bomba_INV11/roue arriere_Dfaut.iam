# Autodesk Inventor assembly: roue arriere_Dfaut
## iProperties
Created: 2006-03
Part Number: roue arriere_Dfaut
Document SubType Name: Assembly
Designer: Flavien MARTY
Author: Flavien MARTY
