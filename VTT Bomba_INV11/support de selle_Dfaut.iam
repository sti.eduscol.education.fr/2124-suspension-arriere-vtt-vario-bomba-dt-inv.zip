# Autodesk Inventor assembly: support de selle_Dfaut
## iProperties
Created: 2006-03
Part Number: support de selle_Dfaut
Document SubType Name: Assembly
Designer: Flavien MARTY
Author: Flavien MARTY
