# Autodesk Inventor part: Corps
## iProperties
Created: 2006-03
Part Number: Corps
Document SubType Name: Modeling
Designer: Flavien MARTY
Author: Flavien MARTY
## Feature names
1. Base1
