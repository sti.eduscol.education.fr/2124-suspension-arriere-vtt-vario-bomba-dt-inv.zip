# Autodesk Inventor part: Axe_Dfaut
## iProperties
Created: 2006-03
Part Number: Axe_Dfaut
Document SubType Name: Modeling
Designer: Flavien MARTY
Author: Flavien MARTY
## Feature names
1. Base1
