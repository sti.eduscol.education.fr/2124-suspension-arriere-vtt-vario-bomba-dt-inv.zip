# Autodesk Inventor assembly: bras oscillant_Dfaut
## iProperties
Created: 2006-03
Part Number: bras oscillant_Dfaut
Document SubType Name: Assembly
Designer: Flavien MARTY
Author: Flavien MARTY
